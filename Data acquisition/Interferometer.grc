options:
  parameters:
    generate_options: qt_gui
    id: Interferometer
    output_language: python
    title: Interferometer
  states: {}

blocks:
- name: Filename5
  id: variable
  parameters:
    value: '"A5_L"+LaptopN+"_O"+ObservationN+"_D"+date'
  states: {}
- name: Filename6
  id: variable
  parameters:
    value: '"A6_L"+LaptopN+"_O"+ObservationN+"_D"+date'
  states: {}
- name: Filename7
  id: variable
  parameters:
    value: '"A7_L"+LaptopN+"_O"+ObservationN+"_D"+date'
  states: {}
- name: Filename8
  id: variable
  parameters:
    value: '"A8_L"+LaptopN+"_O"+ObservationN+"_D"+date'
  states: {state: disabled}
- name: Filename9
  id: variable
  parameters:
    value: '"A9_L"+LaptopN+"_O"+ObservationN+"_D"+date'
  states: {state: disabled}
- name: LaptopN
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: ObservationN
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1.420e9
  states: {}
- name: channels
  id: variable
  parameters:
    value: '512'
  states: {}
- name: date
  id: variable
  parameters:
    value: datetime.datetime.now().strftime("%Y_%d_%m_%H_%M")
  states: {state: disabled}
- name: date
  id: variable
  parameters:
    value: '"date"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2500000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: airspy2
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: airspy0
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: airspy1
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: airspy3
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_3
  id: blocks_file_sink
  parameters:
    file: airspy4
    type: complex
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import datetime
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"airspy=0,bias=1,linearity"'
    bb_gain0: '0'
    freq0: center_freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: '"airspy=2,bias=1,linearity"'
    bb_gain0: '0'
    freq0: center_freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0_0_0
  id: osmosdr_source
  parameters:
    args: '"airspy=3,bias=1,linearity"'
    bb_gain0: '0'
    freq0: center_freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0_0_1
  id: osmosdr_source
  parameters:
    args: '"airspy=4,bias=1,linearity"'
    bb_gain0: '0'
    freq0: center_freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0_1
  id: osmosdr_source
  parameters:
    args: '"airspy=1,bias=1,linearity"'
    bb_gain0: '0'
    freq0: center_freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: center_freq
    fftsize: channels
    name: '"Airspy-6"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: center_freq
    fftsize: channels
    name: '"Airspy-5"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: center_freq
    fftsize: channels
    name: '"Airspy-7"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: center_freq
    fftsize: channels
    name: '"Airspy-8"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: center_freq
    fftsize: channels
    name: '"Airspy-9"'
    type: complex
  states: {state: disabled}

connections:
- [osmosdr_source_0, '0', blocks_file_sink_0_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [osmosdr_source_0_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0_0, '0', qtgui_freq_sink_x_0_1, '0']
- [osmosdr_source_0_0_0, '0', blocks_file_sink_0_2, '0']
- [osmosdr_source_0_0_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [osmosdr_source_0_0_1, '0', blocks_file_sink_0_3, '0']
- [osmosdr_source_0_0_1, '0', qtgui_freq_sink_x_0_1_1, '0']
- [osmosdr_source_0_1, '0', blocks_file_sink_0_1, '0']
- [osmosdr_source_0_1, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
