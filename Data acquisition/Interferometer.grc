options:
  parameters:
    generate_options: qt_gui
    id: Interferometer
    output_language: python
    title: Interferometer
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1.420e9
  states: {}
- name: channels
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2500000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: Airspy2
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: Airspy0
    type: complex
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: Airspy1
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"airspy=0,bias=1,linearity"'
    bb_gain0: '0'
    freq0: center_freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: '"airspy=2,bias=1,linearity"'
    bb_gain0: '0'
    freq0: center_freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0_1
  id: osmosdr_source
  parameters:
    args: '"airspy=1,bias=1,linearity"'
    bb_gain0: '0'
    freq0: center_freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: channels
    name: '"Airspy-1"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: channels
    name: '"Airspy-0"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: channels
    name: '"Airspy-2"'
    type: complex
  states: {state: disabled}

connections:
- [osmosdr_source_0, '0', blocks_file_sink_0_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [osmosdr_source_0_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0_0, '0', qtgui_freq_sink_x_0_1, '0']
- [osmosdr_source_0_1, '0', blocks_file_sink_0_1, '0']
- [osmosdr_source_0_1, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
